Commit message: update bowl color, implement fixed orientation planners for bowl, pick and push

File: helping_hands_rl_envs/simulators/urdf/object/bowl/bowl1.urdf (robot description, URDF)
Before this commit: robot bowl.urdf, 2 links, 1 joints
Links:
- link grasp: geometry 
