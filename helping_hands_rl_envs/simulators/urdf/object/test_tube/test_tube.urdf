Commit message: covid_test_env three swab-tube pairs SR 0.96

File: helping_hands_rl_envs/simulators/urdf/object/test_tube/test_tube.urdf (robot description, URDF)
Before this commit: robot test_tube, 3 links, 2 joints
Links:
- link baseLink: mass .02 -> .1
