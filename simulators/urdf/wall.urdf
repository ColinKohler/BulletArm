Commit message: implement heightmap rendering from point cloud

File: simulators/urdf/wall.urdf (robot description, URDF)
Before this commit: robot wall.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.01 2 2; visual box size=0.01 2 2
