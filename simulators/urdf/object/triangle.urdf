Commit message: This is one of those commits where you waited to long and you can not remember what stuff you did.

File: simulators/urdf/object/triangle.urdf (robot description, URDF)
Before this commit: robot 0.urdf, 1 links, 0 joints
Links:
- link baseLink: mass .1 -> 0.1
