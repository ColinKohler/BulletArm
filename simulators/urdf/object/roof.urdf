Commit message: use the triangle collision shape in roof

File: simulators/urdf/object/roof.urdf (robot description, URDF)
Before this commit: robot roof.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=0.obj scale=1.5 1 1; visual mesh filename=0.obj scale=1.5 1 1
