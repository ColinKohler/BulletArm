Commit message: toward implementing house building 3

File: urdf/object/brick_small.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=.15 .05 .05; visual mesh filename=cube.obj scale=.15 .05 .05
