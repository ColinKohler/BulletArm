Commit message: change collision mesh in triangle

File: urdf/object/0.urdf (robot description, URDF)
Before this commit: robot 0.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=0.obj scale=0.7 1. 1.; visual mesh filename=0.obj scale=0.7 1. 1.
